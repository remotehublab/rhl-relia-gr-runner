options:
  parameters:
    generate_options: hb_qt_gui
    id: eye_plot
    output_language: python
    title: Eye Plot
  states: {}

blocks:
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 2 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 3 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 4 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 5 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 6 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 7 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 8 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 9 * time_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 1 * time_delay
    type: float
  states: {}
- name: nop
  id: parameter
  parameters:
    label: Number of Points
    value: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '10'
    size: nop
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '32000'
  states: {}
- name: time_delay
  id: parameter
  parameters:
    label: Time Delay
    value: '40'
  states: {}

connections:
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_delay_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '7']
- [blocks_delay_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '8']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '9']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0_0_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0, '0']
- [pad_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
