options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: trx_am
    output_language: python
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"192.168.1.100"'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    name: QT GUI Plot
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    name: QT GUI Plot
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: red_pitaya_sink_0
  id: red_pitaya_sink
  parameters:
    addr: str(addr)
    corr: '0'
    freq: tx_freq+20000
    port: '1001'
    ptt: 'True'
    rate: samp_rate
  states: {state: disabled}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: str(addr)
    corr: '0'
    freq: tx_freq
    port: '1001'
    rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_sig_source_x_0, '0', red_pitaya_sink_0, '0']
- [red_pitaya_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
